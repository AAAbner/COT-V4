# Keil uVision project COT-M_SDK.uvprojx, settings and files
target COT-M_SDK (5060020::V5.06 (build 20)::ARMCC)
  device: Apollo_512_BGA Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.0.9.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: COT-M_SDK
  AfterMake: fromelf --bin --output bin\COT-M_SDK.bin obj\COT-M_SDK.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: AM_PACKAGE_BGA  keil AM_UTIL_FAULTISR_PRINT
  c include: .\src\include;.\src\driver\startup;.\src\driver\apollo;.\src\driver\bsp;.\src\midle;.\src\2.4gstack;.\src\utils;.\src\osal;.\src\module;.\src\app;.\src\driver\apollo\hal;.\src\driver\apollo\regs;.\src\midle\devices;.\src\midle\sleep;.\src\midle\timers;.\src\midle\vfs;.\src\midle\usart;.\src\midle\flash;.\src\midle\spi;.\src\midle\gpio;.\src\module\log;.\src\module\datapackage;.\src\midle\rtc;.\src\module\mt;.\src\midle\iic
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  scatter file: .\src\driver\startup\hblr24va.sct
  group startup
    ./src/driver/startup/: startup_keil.s
  group app
    ./src/app/: osal_sample.cpp sample_main.cpp sample_ping_pong_app.cpp
  group module
    ./src/module/mt/: cot_mt_task.c cot_mt_uart.c cot_mt_key.c cot_mt_led.c cot_mt_oled.c
    ./src/module/algorithm/: algorithm lib.lib
    ./src/module/datapackage/: base64.c
    ./src/module/log/: log.c
  group 2.4g stack
    ./src/2.4gstack/: RfParamConfig.cpp COT-M_SDK_RF_LIB.lib COT-M_SDK_RANGING_LIB.lib cot_mac.h
  group osal
    ./src/osal/: osal.c osal_memory.c osal_mutex.c osal_tick.c osal_time.c osal_pwrmgr.c
  group utils
    ./src/utils/: am_util_cmdline.c am_util_debug.c am_util_delay.c am_util_faultisr.c am_util_math.c am_util_plot.c am_util_ring_buffer.c am_util_stdio.c am_util_stopwatch.c am_util_string.c am_util_stxetx.c am_util_tap_detect.c am_util_time.c
  group middle
    ./src/midle/vfs/: COT-M_SDK_VFS_LIB.lib
    ./src/midle/timers/: hal_timers.c
    ./src/midle/usart/: uart.c
    ./src/midle/flash/: flash.c
    ./src/midle/spi/: spi.c spi1.c
    ./src/midle/gpio/: gpio.c
    ./src/midle/rtc/: rtc.c
    ./src/midle/adc/: adc.c
    ./src/midle/sleep/: sleep.c
    ./src/midle/iic/: iic.c
  group driver
    ./src/driver/bsp/: am_bsp.c
    ./src/driver/apollo/hal/: am_hal_adc.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_global.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_itm.c am_hal_mcuctrl.c am_hal_otp.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_sysctrl.c am_hal_systick.c am_hal_tpiu.c am_hal_uart.c am_hal_vcomp.c am_hal_wdt.c
  group readme
    ./: readme.txt
